Commit message: imu_tf

File: launch_start/configuration_files/my_robot_3d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_3d, 3 links, 2 joints
Joints:
- joint vlp16_link_joint: origin xyz=0. 0.1 0. rpy=0. 0. 0. -> xyz=0. 0. 0. rpy=0. 0. 0.
